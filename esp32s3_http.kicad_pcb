# Repository sanbungi/potato-esp32

File README.md:

# potato esp32 (WIP)

ESP32-S3で自作HTTPサーバーを移植して、実際にサイトとして稼働させようプロジェクト

## KiCad design esp32s3_http.kicad_pcb

Parts:
C1: 22uF/10V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2, C3: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C4, C10: 4.7uF/10V; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C5, C6: 15pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C7: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C8: 22uF/10V Ta; CP_EIA-3528-21_Kemet-B_HandSolder
C9: 1uF/25V; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C11, C12: 1000uF/6.3V OS-CON; CP_Radial_D8.0mm_P3.50mm; MPN 6SEPC1000MD
D1, D2, D3: 1N5819; D_DO-41_SOD81_P7.62mm_Horizontal
D4: Red; LED_D3.0mm
D5: Green; LED_D3.0mm
D6: Yellow; LED_D3.0mm
D7, D8: Orange; LED_D3.0mm
J1: 5075BR-04; USB_B_5075BR-04
J2: MJ-179PH; DCJack_MJ-179PH
J3: EXP1_UART; PinHeader_2x04_P2.54mm_Vertical
J4: EXP2; PinHeader_2x06_P2.54mm_Vertical
JP1: W5500 PWR; SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm_NumberL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
JP2: SD PWR; SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm_NumberL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
R1, R2: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4, R5, R6, R7, R8: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1, SW2: TS-06104; SW_TS-06104
U1: ESP32-S3-WROOM-1
U2: LM2940T-3.3; TO-220-3_Vertical
U3: NJM7805FA; TO-220F-3_Vertical
U4: W5500_Module
U5: SDCard_Module
U6: LXDC55_Akizuki
Y1: 32.768KHz; Crystal_Round_D2.0mm_Vertical

Connections:
5V: C4.2, D2.1 (K), D3.1 (K), J4.1, JP1.3 (B), JP2.1 (A), R4.1, U2.1 (VI)
BOOT: R2.1, SW2.2, U1.27 (IO0)
DM: J1.2 (D-), U1.13 (USB_D-)
DP: J1.3 (D+), U1.14 (USB_D+)
EN: C3.2, C7.2, R1.2, SW1.2, U1.3 (EN)
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.2, C9.1, C10.1, C11.2, C12.2, D4.1 (K), D5.1 (K), D6.1 (K), J1.4 (GND), J1.SH (Shield), J2.2, J3.6, J4.2, J4.12, SW1.1, SW2.1, U1.1 (GND), U1.40 (GND), U1.41 (GND), U2.2 (GND), U3.2 (GND), U4.1 (GND), U4.2 (GND), U4.7 (GND), U5.1 (GND), U6.2 (G)
GPIO1: J3.2, U1.39 (IO1)
GPIO2: J3.4, U1.38 (IO2)
GPIO3: J4.4, U1.15 (IO3)
GPIO4: J4.11, U1.4 (IO4)
GPIO5: J4.10, U1.5 (IO5)
GPIO6: J4.9, U1.6 (IO6)
GPIO7: J4.8, U1.7 (IO7)
GPIO8: J4.5, U1.12 (IO8)
GPIO17: J4.7, U1.10 (IO17)
GPIO18: J4.6, U1.11 (IO18)
GPIO42: J3.5, U1.35 (IO42)
GPIO47: J3.7, U1.24 (IO47)
GPIO48: J3.8, U1.25 (IO48)
JACK5V: C10.2, D3.2 (A), U3.3 (VO), U6.3 (VOUT)
LED_STAT: R6.1, U1.23 (IO21)
unnamed: D1.2 (A), J2.1
unnamed: C9.2, D1.1 (K), U3.1 (VI), U6.1 (IN)
unnamed: D4.2 (A), R4.2
unnamed: D5.2 (A), R5.2
unnamed: D6.2 (A), R6.2
unnamed: D7.1 (K), R7.1
unnamed: D8.1 (K), R8.1
unnamed: C5.2, U1.8 (IO15), Y1.1
unnamed: C6.2, U1.9 (IO16), Y1.2
SD_CS: R8.2, U1.31 (IO38), U5.6 (CS)
SD_MISO: U1.34 (IO41), U5.3 (MISO)
SD_MOSI: U1.33 (IO40), U5.4 (MOSI)
SD_SCK: U1.32 (IO39), U5.5 (SCK)
SD_VCC: JP2.2 (C), U5.2 (5V)
U0RXD: J3.3, U1.36 (RXD0)
U0TXD: J3.1, U1.37 (TXD0)
VBUS: D2.2 (A), J1.1 (VBUS)
VDD33: C1.2, C2.2, C8.1, C12.1, D7.2 (A), D8.2 (A), J4.3, JP1.1 (A), JP2.3 (B), R1.1, R2.2, R5.1, U1.2 (3V3), U2.3 (VO)
W5500_CS: R7.2, U1.21 (IO13), U4.5 (CS)
W5500_MISO: U1.19 (IO11), U4.3 (MO)
W5500_MOSI: U1.17 (IO9), U4.12 (MI)
W5500_NT: U1.22 (IO14), U4.6 (NT)
W5500_RST: U1.18 (IO10), U4.11 (RST)
W5500_SCK: U1.20 (IO12), U4.4 (SCK)
W5500_VCC: C11.1, JP1.2 (C), U4.8 (3.3V), U4.9 (3.3V)

Notes on the sheet:
電源切替ジャンパ (1-2 はパターンで接続済み) JP1 W5500: 既定 3.3V / 5V 化は 1-2 カット → 2-3 ハンダ JP2 SD: 既定 5V / 3.3V 化は 1-2 カット → 2-3 ハンダ

Board: 2 copper layers, 55.0 x 90.0 mm, 46 parts (2 on the bottom side), 46 nets.

Other parts of the board:
H1, H2, H3, H4: MountingHole_3.2mm_M3

File bom_akizuki.csv:

リファレンス,品名,型番,秋月通販コード,単価(円),入数,必要数,購入単位数,小計(円),備考
U1,Wi-Fiモジュール ESP32-S3-WROOM-1 (16MB/8MB PSRAM),ESP32-S3-WROOM-1-N16R8,117256,800,1,1,1,800,
U2,低損失三端子レギュレーター 3.3V1A,LM2940T-3.3,114505,80,1,1,1,80,
U3,三端子レギュレーター 5V1.5A,NJM7805FA,108678,60,1,1,1,60,U3/U6 はどちらか一方を実装
U6,LXDC55使用DCDCコンバーターキット (降圧 5V),AE-LXDC55-5V,109981,450,1,1,1,450,任意 (U3 の代わり)。入力 6-14V。ピン順は説明書で確認
D1-D3,ショットキーバリアダイオード 40V1A,1N5819,117244,100,10,3,1,100,
C11-C12,OS-CON 1000uF6.3V105℃,6SEPC1000MD,108293,90,1,2,2,180,
C8,チップタンタルコンデンサー 22uF10V 3528,TAJB226M010R,101408,100,10,1,1,100,LM2940 の出力条件 (22uF 以上・ESR 0.1-1Ω) ぎりぎり
C1,チップ積層セラミックコンデンサー 22uF25V X5R 2012,,108240,120,10,1,1,120,
C2-C3,チップ積層セラミックコンデンサー 0.1uF50V 1608,GRM188F11H104ZA01,113374,100,40,2,1,100,
C4/C10,チップ積層セラミックコンデンサー 4.7uF10V F 1608,GRM188F11A475ZE20,109218,200,50,2,1,200,
C7/C9,チップ積層セラミックコンデンサー 1uF25V B 1608,,130397,100,40,2,1,100,C9 は 7805 入力 (ジャック電圧) のため 25V 品
C5-C6,チップ積層セラミックコンデンサー 15pF50V NP0 1608,CC0603N150J500,113312,100,40,2,1,100,水晶の負荷容量に応じて要調整
R1-R2,チップ抵抗 1608 10kΩ,RK73B1JTTD103J,130355,150,100,2,1,150,
R4-R8,チップ抵抗 1608 1kΩ,RK73B1JTTD102J,130351,150,100,5,1,150,R4 (PWR LED) は 5V で約 3mA
D4,3mm 赤色 LED,OSR5JA3Z74A,111577,10,1,1,1,10,PWR
D5,3mm 緑色 LED,OSG5TA3Z74A,111635,20,1,1,1,20,3V3
D6,3mm 黄色 LED,OSY5JA3Z74A,111639,20,1,1,1,20,STAT
D7-D8,3mm オレンジ色 LED 低消費,OSO5PA3133A-1MA,116909,230,10,2,1,230,LAN / SD
J1,基板取付用 USB コネクター B タイプ メス,5075BR-04-WH,100161,50,1,1,1,50,専用フットプリント esp32s3_http:USB_B_5075BR-04
J2,2.1mm 標準 DC ジャック 基板取付用,MJ-179PH,106568,40,1,1,1,40,専用フットプリント esp32s3_http:DCJack_MJ-179PH
J3/J4,ピンヘッダー 2x40 (80P),PH-2x40SG,100082,70,1,1,1,70,2x4 と 2x6 に切って使用
SW1-SW2,タクトスイッチ 表面実装 6x6mm,TS-06104,115969,30,1,2,2,60,専用フットプリント esp32s3_http:SW_TS-06104
Y1,クリスタル 32.768kHz 円筒 2x6mm,VT-200-F,104005,30,1,1,1,30,
U4,W5500 イーサネットモジュール (12ピン),,,,,1,,,秋月に取扱なし (Amazon 等で調達)
U5,microSD カードモジュール (5V/レベル変換付き 6ピン),,,,,1,,,秋月に取扱なし。AE-MICRO-SD-DIP (105488) はピン配置・電源が異なる
合計,,,,,,,,3220,U4/U5・送料を除く。価格と在庫は 2026-10-04 時点
